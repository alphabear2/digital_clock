# Keil uVision project OldDIYClock.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W1K16S STC
  cpu: IRAM(0-0xFF) XRAM(0-0x2FF) IROM(0-0x3FF8) CLOCK(35000000) MODP2
  output: OldDIYClock +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\OldDIYClock-master
  group DS3231 DIY Clock
    ./: STARTUP.A51 main.c display.c fonts.c rtc.c i2c.c delay.c key.c settings.c alarm.c eeprom.c timer.c holidays.c bmxx80.c si7021.c
